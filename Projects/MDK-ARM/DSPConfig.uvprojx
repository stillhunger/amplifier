# Keil uVision project DSPConfig.uvprojx, settings and files
target DSPConfig Configuration (ARM-ADS)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSPConfig Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\libs\lukheengine;D:\libs\lukheengine\audio;D:\libs\lukheengine\audio\components;D:\libs\lukheengine\platform\stm32f4\audio;D:\libs\lukheengine\processing
  asm include: ..\..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group application
    ../../Src/: main.cpp stm32f4xx_hal_msp.cpp
  group lukheengine/audio
    D:/libs/lukheengine/audio/: abstractaudiodriver.cpp engine.cpp
  group lukheengine/audio/components
    D:/libs/lukheengine/audio/components/: audiocomponent.cpp randomcomponent.cpp track.cpp
  group lukheengine/platform/stm32f4/audio
    D:/libs/lukheengine/platform/stm32f4/audio/: stm32f4audiodriver.cpp stm32f4audiodriver_it.cpp
  group lukhe/processing
    D:/libs/lukheengine/processing/: sigmadeltamodulator.cpp
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.2.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
    RTE/Device/STM32F411RETx/: startup_stm32f411xe.s system_stm32f4xx.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2S 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:TIM 1.1.0, Device:Startup 2.1.0
